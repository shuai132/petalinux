SRC_URI += "file://user_2019-06-25-19-29-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

